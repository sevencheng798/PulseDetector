# IAR project PulseMisc_x8.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32E103x8 GD GD32E103x8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USB_FS; GD32E10X; GD32E103V_EVAL; GD_SOFT_SIMULATION_IIC
  ICCARM.CCIncludePath2: ..\..\..\GD32E10x_Firmware_Library\Utilities; ..\..\..\GD32E10x_Firmware_Library\Firmware\GD32E10x_standard_peripheral\Include; ..\..\..\GD32E10x_Firmware_Library\Firmware\CMSIS; ..\..\..\GD32E10x_Firmware_Library\Firmware\CMSIS\GD\GD32E10x\Include; ..\..\..\GD32E10x_Firmware_Library\Firmware\GD32E10x_usbfs_library\device\class\cdc\Include; ..\..\..\GD32E10x_Firmware_Library\Firmware\GD32E10x_usbfs_library\device\core\Include; ..\..\..\GD32E10x_Firmware_Library\Firmware\GD32E10x_usbfs_library\driver\Include; ..\..\..\GD32E10x_Firmware_Library\Firmware\GD32E10x_usbfs_library\ustd\common; ..\..\..\GD32E10x_Firmware_Library\Firmware\GD32E10x_usbfs_library\ustd\class\cdc; ..; ..\cdc; ..\..\..\Middlewares\Third_Party\FreeRTOSv10.1.1\FreeRTOS\Source\include; ..\..\..\Middlewares\Third_Party\FreeRTOSv10.1.1\FreeRTOS\Source\CMSIS_RTOS; ..\..\..\Middlewares\Third_Party\FreeRTOSv10.1.1\FreeRTOS\Source\portable\IAR\ARM_CM4F
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..
  OBJCOPY.OOCOutputFile: PulseMisc_x8.hex
  ILINK.IlinkOutputFile: PulseMisc_x8.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application
    ../: DTSensingDA55M.c gd32e10x_it.c gd32e10xx_hal.c HP5804.c main.c PulseCMD.c PulseMisc.c
  group Application/cdc
    ../cdc/: gd32e10x_hw.c
  group Application/i2c
    ../i2c/: gd32e10xx_iic_warpper.c
  group Drivers/CMSIS
    ../../../GD32E10x_Firmware_Library/Firmware/CMSIS/GD/GD32E10x/Source/: system_gd32e10x.c
  group Drivers/GD32E10x_Peripherals
    ../../../GD32E10x_Firmware_Library/Firmware/GD32E10x_standard_peripheral/Source/: gd32e10x_dbg.c gd32e10x_dma.c gd32e10x_exmc.c gd32e10x_exti.c gd32e10x_fmc.c gd32e10x_fwdgt.c gd32e10x_gpio.c gd32e10x_i2c.c gd32e10x_misc.c gd32e10x_pmu.c gd32e10x_rcu.c gd32e10x_rtc.c gd32e10x_timer.c gd32e10x_usart.c gd32e10x_wwdgt.c
  group Drivers/GD32E10x_usbfs_library/Class
    ../../../GD32E10x_Firmware_Library/Firmware/GD32E10x_usbfs_library/device/class/cdc/Source/: cdc_acm_core.c
  group Drivers/GD32E10x_usbfs_library/Devices
    ../../../GD32E10x_Firmware_Library/Firmware/GD32E10x_usbfs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group Drivers/GD32E10x_usbfs_library/Driver
    ../../../GD32E10x_Firmware_Library/Firmware/GD32E10x_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
  group GD32E10x_EVAL
    ../../../GD32E10x_Firmware_Library/Utilities/: gd32e10x_eval.c
  group Middlewares/FreeRTOS
    ../../../Middlewares/Third_Party/FreeRTOSv10.1.1/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../../Middlewares/Third_Party/FreeRTOSv10.1.1/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../Middlewares/Third_Party/FreeRTOSv10.1.1/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../Middlewares/Third_Party/FreeRTOSv10.1.1/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Startup
    ../../../GD32E10x_Firmware_Library/Firmware/CMSIS/GD/GD32E10x/Source/IAR/: startup_gd32e10x.s
