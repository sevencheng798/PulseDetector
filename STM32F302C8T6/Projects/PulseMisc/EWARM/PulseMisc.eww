<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\PulseMisc.ewp</path>
    </project>
    <batchBuild />
</workspace>
